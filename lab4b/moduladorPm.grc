options:
  parameters:
    generate_options: qt_gui
    id: moduladorPm
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '0.000001'
    stop: '1'
    value: '1'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '0.000001'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora
    start: '50000000'
    step: '1000000'
    stop: '2000000000'
    value: '50000000'
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia mensaje
    start: '1000'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: kp
  id: variable_qtgui_range
  parameters:
    label: coeficiente kp
    start: '0'
    step: '0.000001'
    stop: '50'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '6250000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: envolCom_0
  id: envolCom
  parameters:
    Ac: Ac
    Kp: kp
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: fc
    fftsize: '8192'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', envolCom_0, '0']
- [envolCom_0, '0', qtgui_freq_sink_x_0, '0']
- [envolCom_0, '0', qtgui_time_sink_x_0, '0']
- [envolCom_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
