options:
  parameters:
    author: Eliana_Gonzalez_Kevin_Bautista_B1B_G2
    generate_options: qt_gui
    id: lab1_punto5
    output_language: python
    title: lab1_punto5_audio
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: frequencia de muestreo
    rangeType: int
    start: '1000'
    step: '1000'
    stop: '300000'
    value: '200000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Escritorio/kevin_eliana/lab1b/despecha_rosalia (1).wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: fff
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle_0, '0', audio_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
