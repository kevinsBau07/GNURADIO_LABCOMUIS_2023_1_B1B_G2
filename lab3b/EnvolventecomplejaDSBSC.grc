options:
  parameters:
    author: labB1B2
    category: '[ModulosB1B2]'
    copyright: Uis
    generate_options: hb
    id: EnvolventecomplejaDSB_SC
    output_language: python
    title: EnvolventecomplejaDSB_SC
  states: {}

blocks:
- name: Ac
  id: parameter
  parameters:
    label: Amplitud portadora
    type: eng_float
    value: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Ac
    type: complex
  states: {}
- name: pad
  id: pad_source
  parameters:
    label: m1(t)
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source
  id: pad_source
  parameters:
    label: m2(t)
    type: float
  states: {}

connections:
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', pad_sink_0, '0']
- [pad, '0', blocks_float_to_complex_0, '0']
- [pad_source, '0', blocks_float_to_complex_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
