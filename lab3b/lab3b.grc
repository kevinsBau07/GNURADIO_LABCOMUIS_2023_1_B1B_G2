options:
  parameters:
    author: labB1B2
    copyright: Uis
    generate_options: qt_gui
    id: TransmisorAm
    output_language: python
    title: Transmisor Am
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud modulante
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '1'
  states: {}
- name: AC
  id: variable_qtgui_range
  parameters:
    label: 'Amplitud portadora '
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '0.1'
  states: {}
- name: GRX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del RX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del TX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: K1
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: K2
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente Ka
    start: '0'
    step: '0.0001'
    stop: '4'
    value: '1'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuncia portadora
    start: '50000000'
    step: '1000000'
    stop: '2200000000'
    value: '50000000'
  states: {}
- name: fc_RX
  id: variable_qtgui_range
  parameters:
    label: frecuncia portadora RX
    start: '50000000'
    step: '1000000'
    stop: '2200000000'
    value: '50000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: samp_rate2
  id: variable_qtgui_range
  parameters:
    label: frecuencia de muestreo
    start: '1000'
    step: '1000'
    stop: '300000'
    value: '200000'
    widget: slider
  states: {state: disabled}
- name: CALCULODEPOTENCIAJ1C_0
  id: CALCULODEPOTENCIAJ1C
  parameters:
    I_vect: '1024'
  states: {state: disabled}
- name: EnvolventecomplejaDSB_SC_0
  id: EnvolventecomplejaDSB_SC
  parameters:
    Ac: '0.1'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: audio_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: K1
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: K2
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Escritorio/kevin_eliana/lab3b/edacecar_bbc_trenes (4).wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Descargas/despecha_rosalia.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    nconnections: '3'
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    plotconst: 'False'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: samp_rate
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: audio_rate
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: audio_rate
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: samp_rate
    type: fff
  states: {}
- name: st
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc_RX
    gain0: GRX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [EnvolventecomplejaDSB_SC_0, '0', blocks_complex_to_mag_0, '0']
- [EnvolventecomplejaDSB_SC_0, '0', qtgui_freq_sink_x_0, '0']
- [EnvolventecomplejaDSB_SC_0, '0', qtgui_time_sink_x_0, '0']
- [EnvolventecomplejaDSB_SC_0, '0', st, '0']
- [analog_sig_source_x_0, '0', CALCULODEPOTENCIAJ1C_0, '0']
- [analog_sig_source_x_0, '0', EnvolventecomplejaDSB_SC_0, '0']
- [analog_sig_source_x_0_0, '0', EnvolventecomplejaDSB_SC_0, '1']
- [blocks_complex_to_float_0, '0', rational_resampler_xxx_0_0_0, '0']
- [blocks_complex_to_float_0, '1', rational_resampler_xxx_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_float_to_complex_0_0_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '2']
- [blocks_float_to_complex_0_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_float_to_complex_0_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '1']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_1, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', EnvolventecomplejaDSB_SC_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_complex_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_1, '0', EnvolventecomplejaDSB_SC_0, '1']
- [rational_resampler_xxx_1, '0', blocks_float_to_complex_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_float_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
